File: MCU/MCU.kicad_sch (KiCad schematic)
At the start: 4 parts

Commit message: Up
Other:
- moved on the sheet: H1, H2, H3, H4
